# Keil uVision project f431cbu6.uvprojx, settings and files
target f431cbu6 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: f431cbu6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../lib/foc;../lib;../lib/foc/src;../lib/foc/include;../lib/foc/include/hal;../lib/foc/hal;../foc_app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fdcan.c i2c.c rtc.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group foc
    ../lib/foc/src/: can_protocol.c clarke.c comm_host.c filter.c foc_control.c foc_core.c foc_fault.c foc_sense.c park.c pi_ctrl.c svpwm.c
    ../lib/foc/include/: can_protocol.h clarke.h comm_host.h filter.h foc.h foc_config.h foc_control.h foc_core.h foc_fault.h foc_types.h park.h pi_ctrl.h svpwm.h
    ../lib/foc/include/hal/: hal_can.h hal_current.h hal_encoder.h hal_pwm.h
  group app
    ../foc_app/: foc_main_g431.c foc_main_g431.h
    ../lib/foc/hal/: hal_stm32g4_can.c hal_stm32g4_current.c hal_stm32g4_encoder.c hal_stm32g4_pwm.c hal_stm32g4_uart.c
software components: CMSIS:CORE 4.3.0
